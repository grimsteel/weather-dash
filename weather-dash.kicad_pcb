# Repository grimsteel/weather-dash

File README.md:

# Weather Dashboard

> LCD weather dash powered by an ESP32-S2 and a 1.8" TFT

## Case

[Onshape](https://cad.onshape.com/documents/d06c112e58f115f3ec29811b/w/2a8c46b6d89bea48d93f043a/e/2a97cfce612bd0256a92786b?renderMode=0&uiState=676c6f4b24d20336a44b9517)

**Switch to the "Demo" named view!**

## PCB

[Kicanvas](https://kicanvas.org/?github=https%3A%2F%2Fgithub.com%2Fgrimsteel%2Fweather-dash%2Fblob%2Fmain%2Fweather-dash.kicad_pro)

### Major Components:

- Wemos S2 Mini
- 1.8" TFT
- DHT11 temp/humidity sensor
- Li-ion battery charger

### Voltage Calculations:

1. ESP32-C3 requires 3.0-3.6V input voltage
2. The LDO technically requires 4.3V for a stable 3.3V, _but_ starts providing 3.0V at an input of ~3.1V
3. The battery is 3.8V
4. The 1N5817 Schottky has a voltage drop of 0.25V at 200 mA
5. Therefore, the LDO will be provided with 3.45V and will output 3.2-3.3V

## KiCad design weather-dash.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
D1: 1N5817; D_DO-41_SOD81_P7.62mm_Horizontal
J1: Conn_01x02_Pin; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J3: Conn_01x03_Socket; DHT11
R1: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1, SW3: SW_Push; SW_PUSH_6mm_H4.3mm
SW2: SW_SPST; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
U1: WEMOS_S2_Mini
U2: TFT_ST7735_SD
U3: TP4056

Connections:
+3.3V: J3.2, R1.1, U1.8 (3V3), U2.1 (3V3)
BAT+: J1.2, U3.0 (BAT+)
BAT-: J1.1, U3.1 (BAT-)
BTN1: SW1.1, U1.22 (IO17)
BTN2: SW3.1, U1.16 (IO14)
BUZ: BZ1.1 (+), U1.17 (IO40)
DHT11: J3.1, U1.25 (IO39)
GND: BZ1.2 (-), J3.3, SW1.2, SW3.2, U1.23 (GND), U2.2 (GND), U3.3 (OUT-)
MISO: U1.26 (IO37/MISO), U2.11 (SD_MISO)
MOSI: U1.27 (IO35/MOSI), U2.6 (LCD_MOSI), U2.10 (SD_MOSI)
unnamed: D1.2 (A), U3.2 (OUT+)
unnamed: D1.1 (K), SW2.1 (A)
unnamed: R1.2, U2.8 (LED)
SCK: U1.19 (IO36/SCK), U2.7 (LCD_SCK), U2.12 (SD_SCK)
SD_CS: U1.9 (IO1), U2.9 (SD_CS)
TFT_CS: U1.20 (IO34/CS0), U2.3 (LCD_CS)
TFT_DC: U1.28 (IO33), U2.5 (D/C)
TFT_EN: U1.18 (IO38), U2.4 (EN)
VBUS: SW2.2 (B), U1.32 (VBUS)

Notes on the sheet:
BUTTON 2
BUTTON 1
ESP32-C3
POWER + CHARGING
TFT
DHT11
BUZZER
BATTERY

Board: 2 copper layers, 61.0 x 46.0 mm, 11 parts (7 on the bottom side), 19 nets.

## Commit log

2024-12-13 some changes
    idk what they are
2024-12-25 more pcb changes
2024-12-25 readme updates
2024-12-25 update kicanvas link
2025-01-26 pcb updates
2025-01-26 add firmware
2025-04-01 update pcb format
